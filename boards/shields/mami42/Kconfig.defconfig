## boards/shields/mami42/Kconfig.defconfig
```kconfig
if SHIELD_MAMI42

config ZMK_KEYBOARD_NAME
    default "mami42"

endif # SHIELD_MAMI42
```
